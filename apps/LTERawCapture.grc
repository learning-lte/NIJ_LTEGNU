<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.14'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>LTERawCapture</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>file_suffix</value></param>
<param><key>value</key><value>"2.10_2.98_3_0"</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>1880e6</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>900e6</value></param>
<param><key>step</key><value>1e6</value></param>
<param><key>stop</key><value>2.6e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>1880e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>0.75</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>0.750</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>6e6</value></param>
<param><key>option2</key><value>11e6</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>7.68e6</value></param>
<param><key>labels</key><value>["5 MHz", "10 MHz", "15 MHz", "19 MHz", "20 MHz", "21MHz", "25MHz","40 MHz", "50 MHz", "56 MHz"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[5e6, 10e6, 15e6, 19e6, 20e6, 21e6, 25e6, 40e6, 50e6, 56e6, 60e6, 7.68e6]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>7.68e6</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>"/home/nij/GNU/RawData/lte_ant1_" + file_suffix</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>file</key><value>"/home/nij/GNU/RawData/lte_ant2_" + file_suffix</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"Raw time Sink"</value></param>
<param><key>size</key><value>7680*2</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>0</value></param>
<param><key>tr_tag</key><value></value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ylabel</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>True</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>ant1</key><value>RX2</value></param>
<param><key>center_freq1</key><value>uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)</value></param>
<param><key>dc_offs_enb1</key><value>True</value></param>
<param><key>iq_imbal_enb1</key><value>False</value></param>
<param><key>norm_gain1</key><value>True</value></param>
<param><key>gain1</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>"name=SDR4"</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>start_time</key><value>-1</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
